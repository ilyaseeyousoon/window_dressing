# Keil uVision project SCFL_FW_1_0.uvprojx, settings and files
target STM32F207_SCFL_Driver_3_0 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F207VGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SCFL_FW_1_0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./User/: Main.c Init.c Retarget.c Serial.c IRQ.c
software components: CMSIS:CORE 4.1.0, CMSIS Driver:SPI 2.02, Device:STM32Cube Framework:Classic 1.0.1, Device:STM32Cube HAL:ADC 1.0.1, Device:STM32Cube HAL:CAN 1.0.1, Device:STM32Cube HAL:Common 1.0.1, Device:STM32Cube HAL:Cortex 1.0.1, Device:STM32Cube HAL:DAC 1.0.1, Device:STM32Cube HAL:DMA 1.0.1, Device:STM32Cube HAL:Flash 1.0.1, Device:STM32Cube HAL:GPIO 1.0.1, Device:STM32Cube HAL:I2C 1.0.1, Device:STM32Cube HAL:RCC 1.0.1, Device:STM32Cube HAL:SPI 1.0.1, Device:STM32Cube HAL:TIM 1.0.1, Device:STM32Cube HAL:UART 1.0.1, Device:Startup 2.0.1
